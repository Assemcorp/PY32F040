# Keil uVision project Project.uvprojx, settings and files
target Project (6120000::V6.12::.\ARMCLANG)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F040xB
  c include: ..\Inc;..\Drivers\BSP\PY32F040xx_Start_Kit;..\Drivers\CMSIS\Device\PY32F040\Include;..\Drivers\BSP\PY32F040xx_Start_Kit;..\Drivers\PY32F040_HAL_Driver\Inc;..\Drivers\PY32F040_HAL_Driver\Src;..\Drivers\CMSIS\Device\PY32F040\Include;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f040xx.s
    ../Src/: system_py32f040.c
  group Application/User
    ../Src/: main.c py32f040_hal_msp.c py32f040_it.c
  group BSP/py32f040xx_Start_Kit
    ../Drivers/BSP/PY32F040xx_Start_Kit/: py32f040xx_Start_Kit.c
  group Drivers/PY32F040_HAL_Driver
    ../Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_cortex.c py32f040_hal_dma.c py32f040_hal_gpio.c py32f040_hal_pwr.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_uart.c py32f040_ll_usart.c
    ../../../Test/PY32F040_Keil_Template/Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal_tim.c py32f040_hal_tim_ex.c py32f040_ll_tim.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
